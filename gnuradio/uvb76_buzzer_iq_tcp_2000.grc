options:
  parameters:
    author: bleez
    description: UVB-76-style buzzer simulation to SimTx
    generate_options: qt_gui
    id: uvb76_buzzer_iq_tcp
    output_language: python
    title: UVB-76 Buzzer IQ TCP
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: buzz_freq
  id: variable
  parameters:
    value: '625'
  states: {}
- name: buzz_rate
  id: variable
  parameters:
    value: 1.0/2.5
  states: {}
- name: buzz_duty
  id: variable
  parameters:
    value: '0.48'
  states: {}
- name: buzz_amp
  id: variable
  parameters:
    value: '0.85'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.07'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: buzz_amp
    freq: buzz_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: noise
  id: analog_noise_source_c
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: envelope
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: buzz_rate
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQUARE_WAVE
  states: {}
- name: envelope_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: multiply
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: tcp_sink
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    eof: 'False'
    mtu: '1472'
    port: '2000'
    type: complex
  states: {}

connections:
- [tone, '0', add, '0']
- [noise, '0', add, '1']
- [add, '0', multiply, '0']
- [envelope, '0', envelope_complex, '0']
- [envelope_complex, '0', multiply, '1']
- [multiply, '0', tcp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
