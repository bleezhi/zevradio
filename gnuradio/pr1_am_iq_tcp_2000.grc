options:
  parameters:
    author: bleez
    description: PR1 mono audio to AM IQ over TCP
    generate_options: qt_gui
    id: pr1_am_iq_tcp
    output_language: python
    title: PR1 AM IQ TCP
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source
  id: audio_source
  parameters:
    device_name: pipewire
    num_inputs: '1'
    sample_rate: samp_rate
    type: float
    vlen: '1'
  states: {}
- name: multiply
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: add
  id: blocks_add_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: zero
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: float_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: tcp_sink
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    eof: 'False'
    mtu: '1472'
    port: '2000'
    type: complex
  states: {}

connections:
- [audio_source, '0', multiply, '0']
- [multiply, '0', add, '0']
- [add, '0', float_to_complex, '0']
- [zero, '0', float_to_complex, '1']
- [float_to_complex, '0', tcp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
